# Keil uVision project simple_spi.uvprojx, settings and files
target STM32F407BETx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: simple_spi
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ./: main.c
  group Liquid Crystal
    ./: LiquidCrystal.c LiquidCrystal.h
  group ADC
    ./: adc.c adc.h
  group SPI driver
    ./: SPI.c SPI.h
software components: CMSIS:CORE 5.3.0, Device:Startup 2.6.3
